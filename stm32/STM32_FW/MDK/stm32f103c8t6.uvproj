# Keil uVision project stm32f103c8t6.uvproj, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103c8t6 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\USER\inc;..\LIBS\CMSIS\CM3\CoreSupport;..\LIBS\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\LIBS\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/src/: stm32f10x_it.c main.c BspGpio.c delay.c myuart.c DHT11.c convert.c motor.c mq2.c ME003.c
  group LIBS
    ../LIBS/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../LIBS/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../LIBS/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StartUp
    ../StartUp/: startup_stm32f10x_md.s
